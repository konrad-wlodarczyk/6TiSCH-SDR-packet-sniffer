options:
  parameters:
    author: Konrad Włodarczyk
    generate_options: qt_gui
    id: main_packet_sniffer
    output_language: python
    realtime_scheduling: '1'
    title: 6TiSCH Packet Sniffer
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: bitrate
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: 12.5e3
  states: {}
- name: gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '(samp_rate/1)/bitrate '
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: taps
  id: variable
  parameters:
    value: |
      firdes.low_pass(1.0, samp_rate, 70e3, 30e3, window.WIN_HAMMING)
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1'
    gate: 'True'
    ramp: '0'
    threshold: '-35'
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1'
    gate: 'True'
    ramp: '0'
    threshold: '-35'
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1'
    gate: 'True'
    ramp: '0'
    threshold: '-35'
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_0_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1'
    gate: 'True'
    ramp: '0'
    threshold: '-35'
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_0_1
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1'
    gate: 'True'
    ramp: '0'
    threshold: '-35'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_0_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_0_0_1
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '15'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '15'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '15'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '15'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_1
  id: blocks_moving_average_xx
  parameters:
    length: '15'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0_1
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: samp_per_sym*(1+0.0)+0.2
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: samp_per_sym*(1+0.0)+0.2
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: samp_per_sym*(1+0.0)+0.2
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: samp_per_sym*(1+0.0)+0.2
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0_1
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: samp_per_sym*(1+0.0)+0.2
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-900e3'
    decim: '1'
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-700e3'
    decim: '1'
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-500e3'
    decim: '1'
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-100e3'
    decim: '1'
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-300e3'
    decim: '1'
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {}
- name: packet_segmenter_0
  id: packet_segmenter
  parameters:
    access_code: '1001000001001110'
    channel: 863.1MHz
    tag_name: Sync Word
    threshold: '0'
  states: {}
- name: packet_segmenter_0_0
  id: packet_segmenter
  parameters:
    access_code: '1001000001001110'
    channel: 863.3 MHz
    tag_name: Sync Word
    threshold: '0'
  states: {}
- name: packet_segmenter_0_0_0
  id: packet_segmenter
  parameters:
    access_code: '1001000001001110'
    channel: 863.5 MHz
    tag_name: Sync Word
    threshold: '0'
  states: {}
- name: packet_segmenter_0_0_0_0
  id: packet_segmenter
  parameters:
    access_code: '1001000001001110'
    channel: 863.9 MHz
    tag_name: Sync Word
    threshold: '0'
  states: {}
- name: packet_segmenter_0_0_1
  id: packet_segmenter
  parameters:
    access_code: '1001000001001110'
    channel: 863.7 MHz
    tag_name: Sync Word
    threshold: '0'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Channel 0 - 863.1 MHz"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Channel 2 - 863.3 MHz"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Channel 4 - 863.5 MHz"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Channel 8 - 863.9 MHz"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Channel 6 - 863.7 MHz"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    center_freq: 864e6
    gain: '20'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_pwr_squelch_xx_0_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [analog_pwr_squelch_xx_0_0_0, '0', analog_quadrature_demod_cf_0_0_0, '0']
- [analog_pwr_squelch_xx_0_0_0_0, '0', analog_quadrature_demod_cf_0_0_0_0, '0']
- [analog_pwr_squelch_xx_0_0_1, '0', analog_quadrature_demod_cf_0_0_1, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_moving_average_xx_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0, '0', blocks_moving_average_xx_0_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0_0, '0', blocks_moving_average_xx_0_0_0_0, '0']
- [analog_quadrature_demod_cf_0_0_1, '0', blocks_moving_average_xx_0_0_1, '0']
- [blocks_moving_average_xx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_moving_average_xx_0_0, '0', digital_clock_recovery_mm_xx_0_0, '0']
- [blocks_moving_average_xx_0_0_0, '0', digital_clock_recovery_mm_xx_0_0_0, '0']
- [blocks_moving_average_xx_0_0_0_0, '0', digital_clock_recovery_mm_xx_0_0_0_0, '0']
- [blocks_moving_average_xx_0_0_1, '0', digital_clock_recovery_mm_xx_0_0_1, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_uchar_to_float_0_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_uchar_to_float_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_uchar_to_float_0_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0_0, '0']
- [blocks_uchar_to_float_0_0_0_1, '0', qtgui_time_sink_x_0_0_0_1, '0']
- [digital_binary_slicer_fb_0, '0', packet_segmenter_0, '0']
- [digital_binary_slicer_fb_0_0, '0', packet_segmenter_0_0, '0']
- [digital_binary_slicer_fb_0_0_0, '0', packet_segmenter_0_0_0, '0']
- [digital_binary_slicer_fb_0_0_0_0, '0', packet_segmenter_0_0_0_0, '0']
- [digital_binary_slicer_fb_0_0_1, '0', packet_segmenter_0_0_1, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_clock_recovery_mm_xx_0_0, '0', digital_binary_slicer_fb_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0_0, '0', digital_binary_slicer_fb_0_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0_0_0, '0', digital_binary_slicer_fb_0_0_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0_1, '0', digital_binary_slicer_fb_0_0_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_pwr_squelch_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_pwr_squelch_xx_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', analog_pwr_squelch_xx_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0, '0', analog_pwr_squelch_xx_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_1, '0', analog_pwr_squelch_xx_0_0_1, '0']
- [packet_segmenter_0, '0', blocks_uchar_to_float_0_0, '0']
- [packet_segmenter_0_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [packet_segmenter_0_0_0, '0', blocks_uchar_to_float_0_0_0_0, '0']
- [packet_segmenter_0_0_0_0, '0', blocks_uchar_to_float_0_0_0_0_0, '0']
- [packet_segmenter_0_0_1, '0', blocks_uchar_to_float_0_0_0_1, '0']
- [soapy_limesdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [soapy_limesdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [soapy_limesdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [soapy_limesdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0, '0']
- [soapy_limesdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
